PRINC := "${@int(PRINC) + 1}"

DEPENDS = "ruby-native zlib openssl"
